# Keil uVision project temprature.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: temprature +hex
  c flags: Optimize=8 SizeSpeed=1
  group src
    ./src/: ds18b20.c dwin.c main.c public.c smg.c uart.c ds18b20.h dwin.h public.h smg.h uart.h
