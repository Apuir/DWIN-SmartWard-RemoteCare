# Keil uVision project NEW_C__S5_S4_S3_S2_8283_RTC.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: New_C_8283 +hex
  AfterMake: .\AfterBuildRun.bat
  c flags: Optimize=3 SizeSpeed=1
  c include: .\Core\Inc;.\Hardware\Inc;.\User\Inc;.\Utils\Inc
  link misc: REMOVEUNUSED
  group User
    ./User/Src/: save_data_dgus.c
  group Core
    ./Core/Src/: Main.c Sys.c
  group Hardware
    ./Hardware/Src/: i2c.c Uart.c
  group Utils
    ./Utils/Src/: crc16.c
